COMPATIBLE_MACHINE_pinephone = "pinephone"
PLATFORM_pinephone = "sun50i_a64"
