IMAGE_INSTALL:append:pinephone = " luneos-recovery-ui key-state"
IMAGE_INSTALL:append:pinephonepro = " luneos-recovery-ui key-state"
