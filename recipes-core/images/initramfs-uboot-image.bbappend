IMAGE_INSTALL:append:pinephone = " luneos-recovery-ui"
IMAGE_INSTALL:append:pinephonepro = " luneos-recovery-ui"
IMAGE_INSTALL:append:pinetab2 = " luneos-recovery-ui"
