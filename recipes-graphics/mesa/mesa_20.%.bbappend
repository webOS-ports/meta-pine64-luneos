# to debug some issues
# EXTRA_OEMESON_append_pinephone = " --buildtype=debug "

PACKAGECONFIG_append_pinephone = " kmsro lima"
